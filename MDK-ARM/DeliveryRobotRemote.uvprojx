# Keil uVision project DeliveryRobotRemote.uvprojx, settings and files
target DeliveryRobotRemote (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Redundant Watchdog +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe  --bin -o "$L@L.bin" "!L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_FULL_LL_DRIVER
  c include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: app_main.c can.c udp.c battery.c mem_pool.c crc32.c
    Web/: web.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407VETx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group Web files
    ./Web/: home.png index.htm pix.png style.css action.js parameters.htm upgrade.htm network.cgi network.htm parameters.cgi upgrade.cgi icon_home.png upgrade_progress.htm version.cgi
  group Application/Network
    ../Src/: HTTP_Server_Error.c HTTP_Server_CGI.c
  group Application/OTA
    ../Src/: w25qxx.c update_file_store.c flash.c reset.c parameter_file_store.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Network:CORE 7.15.0, Network:Interface:ETH 7.15.0, Network:Service:Web Server Compact 7.15.0, Network:Socket:TCP 7.15.0, Network:Socket:UDP 7.15.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, Device:STM32Cube HAL:CAN 1.7.9, Device:STM32Cube HAL:CRC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:ETH 1.7.9, Device:STM32Cube HAL:Flash 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:IWDG 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:UART 1.7.9, Device:STM32Cube LL:CRC 1.7.9, Device:STM32Cube LL:Common 1.7.9, Device:STM32Cube LL:GPIO 1.7.9, Device:STM32Cube LL:PWR 1.7.9, Device:STM32Cube LL:RCC 1.7.9, Device:STM32Cube LL:USART 1.7.9, Device:STM32Cube LL:UTILS 1.7.9, Device:Startup 2.6.3
